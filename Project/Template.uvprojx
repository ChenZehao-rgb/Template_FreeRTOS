# Keil uVision project Template.uvprojx, settings and files
target Template_FreeRTOS (6210000::V6.21::ARMCLANG)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\User;..\Firmware\CMSIS;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Hardware\Include;..\FreeRTOS\Include;..\FreeRTOS\Port\GCC\ARM_CM4F;..\App\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c system.c delay.c sys.h systick.c FreeRTOSConfig.h
  group Hardware
    ../Hardware/Source/: bsp_usart.c bsp_led.c bsp_key.c bsp_pwm.c bsp_basic_timer.c bsp_dma.c bsp_adc.c bsp_i2c.c inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c soft_i2c.c
  group App
    ../App/Source/: motor.c pid.c encoder.c
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_adc.c gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_i2c.c gd32f4xx_spi.c gd32f4xx_timer.c gd32f4xx_usart.c gd32f4xx_syscfg.c
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group FreeRTOS/Src
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Port
    ../FreeRTOS/Port/MemMang/: heap_4.c
    ../FreeRTOS/Port/GCC/ARM_CM4F/: port.c
  group Doc
    ../: README.md
